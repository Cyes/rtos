# Keil uVision project L432KC.uvprojx, settings and files
target L432KC (6160000::V6.16::ARMCLANG)
  device: STM32L432KCUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: L432KC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=4 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L432xx
  c include: ..\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/CMSIS/Include;..\Drivers\CMSIS\Device;..\kernel\include;..\kernel;..\demo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group demo
    ../demo/: main.c bsp .c md5.c
  group kernel
    ../kernel/: kernel.c port.c queue.c task.c timer.c dynamic_block .c
  group Drivers/CMSIS
    ../demo/: startup_stm32l432xx.s
    ../Drivers/CMSIS/Device/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_usart.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_tim.c
software components: CMSIS:CORE 5.4.0
